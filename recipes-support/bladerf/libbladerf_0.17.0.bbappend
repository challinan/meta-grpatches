FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://libbladerf-fix-lib64.patch"
