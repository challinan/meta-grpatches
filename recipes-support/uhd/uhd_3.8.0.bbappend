FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://uhd-fix-lib64.patch"
