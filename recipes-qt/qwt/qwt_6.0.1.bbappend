FILESEXTRAPATHS_prepend := "${THISDIR}/files"

SRC_URI += "file://qwt-fix-install-libs.patch"
