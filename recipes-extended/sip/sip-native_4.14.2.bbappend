FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://sip-debug-printf.patch;patchdir=.."
